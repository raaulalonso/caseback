## firmware/caseback-fw/boards/caseback/caseback_disc/board.yml
```yaml
board:
  name: caseback_disc
  full_name: Caseback Gen 1 disc
  vendor: others
  socs:
    - name: nrf52840
```
